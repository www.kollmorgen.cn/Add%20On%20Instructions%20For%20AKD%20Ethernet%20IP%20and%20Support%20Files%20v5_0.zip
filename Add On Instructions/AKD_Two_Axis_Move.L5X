(* Logix 5000 AddOnInstructionDefinition export AKD_Two_Axis_Move; software revision 19.01; part 3 of 3 *)
(* AKD_Two_Axis_Move, continued *)

ROUTINE Prescan   (* ladder *)
END_ROUTINE
END_ADD_ON_INSTRUCTION
